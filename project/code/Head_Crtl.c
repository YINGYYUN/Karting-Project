/*******************************************************************************
航向外环：目标航向 -> 舵角
给定目标航向，把车拉过去。目标由上层提供（路表 / 纯跟踪）
*******************************************************************************/


#include "zf_common_headfile.h"
#include "ins_imu.h"


/**********************************************************/
/*[S] 内部状态 [S]----------------------------------------*/
/**********************************************************/

// ★ 全部 volatile：Head_Crtl_Tick() 在 5 ms 中断里跑（pit0_ch1_isr），
//   其余接口在页面主循环里调用。跨节拍共享的状态不加 volatile 的话，
//   编译器可以把 Set_Target 写的值缓存在寄存器里，中断永远读到旧值 —— 这类 bug 只在 -O2 下出现。
static volatile uint8 head_en  = 0;         // 1 = 接管 Servo_Target_Deg
static volatile float head_tar = 0.0f;      // 目标航向（累积值）
static volatile float head_err = 0.0f;      // 目标 - 实测，折到 ±180
static volatile float head_kp  = HEAD_KP_DEFAULT;   // 航向环增益（回放会按 2L/ld 覆盖）

/**********************************************************/
/*----------------------------------------[E] 内部状态 [E]*/
/**********************************************************/


/**********************************************************/
/*[S] 内部函数 [S]----------------------------------------*/
/**********************************************************/

//--------------------------------------
// 函数简介     角度差折算到 ±180
// 备注信息     yaw 是累积值，只有做误差时才需要折算
//--------------------------------------
static float Head_Wrap180 (float d)
{
    while (d > 180.0f)  { d -= 360.0f; }
    while (d < -180.0f) { d += 360.0f; }
    return d;
}

/**********************************************************/
/*----------------------------------------[E] 内部函数 [E]*/
/**********************************************************/


/**********************************************************/
/*[S] 接口实现 [S]----------------------------------------*/
/**********************************************************/

//--------------------------------------
// 函数简介     每拍算一次舵角
// 备注信息     不论使能与否都刷新误差；只有使能时才写 Servo_Target_Deg
//--------------------------------------
void Head_Crtl_Tick (void)
{
    head_err = Head_Wrap180(head_tar - ins_imu_get_yaw());

    if (0 == head_en)
    {
        return;
    }

    // δ = −K·err（前进方向的 P 律）。**本层只管前进**：
    // 倒车段不走这个环，而是由 route_pb.c 关掉它、开环回放录制打角
    // （倒车时前视点落在车后，纯跟踪的 α 与这里的误差符号都失去意义）。
    Servo_Target_Deg = -head_kp * head_err;
}

//--------------------------------------
// 函数简介     航向环接管开关
// 备注信息     0->1 那一拍把目标对齐当前航向，防止带着旧目标进来甩一把
//              （上层紧接着 Set_Target 会覆盖它）
//--------------------------------------
void Head_Crtl_Set_Enable (uint8 en)
{
    if ((0 != en) && (0 == head_en))
    {
        head_tar = ins_imu_get_yaw();
    }

    head_en = (0 != en) ? 1 : 0;
}

void Head_Crtl_Set_Target (float yaw_deg)
{
    head_tar = yaw_deg;
}

//--------------------------------------
// 函数简介     设置航向环增益
// 备注信息     夹在 0.3~8：超出这一段不是"更灵敏"，是会振
//--------------------------------------
void Head_Crtl_Set_Kp (float kp)
{
    if (kp < 0.3f) { kp = 0.3f; }
    if (kp > 8.0f) { kp = 8.0f; }

    head_kp = kp;
}

void Head_Crtl_Sync (void)
{
    head_tar = ins_imu_get_yaw();
}

uint8 Head_Crtl_Enabled (void)
{
    return head_en;
}

float Head_Crtl_Get_Target (void)
{
    return head_tar;
}

float Head_Crtl_Get_Err (void)
{
    return head_err;
}

/**********************************************************/
/*----------------------------------------[E] 接口实现 [E]*/
/**********************************************************/
